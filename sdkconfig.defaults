## sdkconfig.defaults
```kconfig
CONFIG_ESPTOOLPY_MONITOR_BAUD_115200=y
CONFIG_ESP_CONSOLE_UART_DEFAULT=y
CONFIG_LOG_DEFAULT_LEVEL_INFO=y
```
